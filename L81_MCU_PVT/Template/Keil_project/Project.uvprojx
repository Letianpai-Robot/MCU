# Keil uVision project Project.uvprojx, settings and files
target GD32L23x (6190000::V6.19::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32L23x\Include;..\TimTask;..\Light_sensor;..\Person_sensor;..\MAG_senser;..\Temp_senser;..\MoveAlgorithm;..\MyTask;..\gyro;..\VI5300_V11\API\inc;..\VI5300_V11\Common;..\VI5300_V11\API\src
  library: MicroLIB
  memory RVCT4: ROM 0x800d000 size 0x2d000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32l23x_it.c gd32l23x_it.h L81_Motors.c L81_Motors.h L81_inf.c L81_inf.h L81_AT.c L81_AT.h qmi8658.c qmi8658.h i2c_inf.c L81_cliff.h i2c_inf.h L81_FMC.c L81_FMC.h L81_cliff.c L81_IR.c L81_IR.h L81_factory.c L81_factory.h L81_ota.c L81_ota.h aw9310x.c L81_rtc.c
    ../Person_sensor/: sths34pf80.c sths34pf80.h sths34pf80_reg.c sths34pf80_reg.h tmos_algo.c tmos_algo.h
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group Peripherals
    ../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_dac.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_rcu.c gd32l23x_syscfg.c gd32l23x_usart.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_dbg.c gd32l23x_fwdgt.c gd32l23x_rtc.c gd32l23x_vref.c gd32l23x_adc.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_fmc.c gd32l23x_i2c.c gd32l23x_lpuart.c gd32l23x_pmu.c gd32l23x_spi.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_wwdgt.c gd32l23x_ctc.c gd32l23x_lptimer.c gd32l23x_slcd.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l23x.s
  group Utilities
    ../../Utilities/: gd32l233r_eval.c
  group Doc
    ../: readme.txt
  group CommCode
    ../TimTask/: L81_TimTask.c
  group SensorLight
    ../Light_sensor/: stk3311iic.c
  group SensorPerson
    ../Person_sensor/: sths34pf80_iic.c
  group SensorMag
    ../MAG_senser/: qmc6308iic.c
  group SensorTemp
    ../Temp_senser/: gxhtc3iic.c
  group MoveAlg
    ../MoveAlgorithm/: L81_MoveAlg.c
  group MyTask
    ../MyTask/: L81_led_task.c L81_sensor_task.c L81_cliff_task .c L81_main_task.c L81_humiture_task.c L81_humiture_task.h L81_infrared_task.c
  group Gyro
    ../gyro/: algorithm.c gyro_oula.c KalmanFilter.c qmi8658iic.c
  group Vi530x
    ../VI5300_V11/Common/: Emu_IIC.c VI530x_Common.c
    ../VI5300_V11/API/src/: VI530x_Algorithm.c VI530x_API.c VI530x_Firmware.c VI530x_System_Data.c VI530x_User_Handle.c
software components: CMSIS:CORE 5.2.0
